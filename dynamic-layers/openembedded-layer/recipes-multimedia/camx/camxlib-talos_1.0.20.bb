PLATFORM = "talos"
PBT_BUILD_DATE = "260426"

require common.inc

SRC_URI[camxlib.sha256sum]     = "8f406d7d8613bb193a042426bb4c72f5917fea0b0fd0e0b42b1925f7b0deaa47"
SRC_URI[camx.sha256sum]        = "733d26978dc436e89ec3f79f224537c530164d4410a68105f7c1a9d021e5797c"
SRC_URI[chicdk.sha256sum]      = "0194a1d990e5873a5fc670de0535e03b8b225b388c9ca8dd08a8b0be7b64c1d0"
SRC_URI[camxcommon.sha256sum]  = "6b050cc0aed123128fbe431bde1b7b0839d0ec2f5d955cbb269a26396c17a07d"
