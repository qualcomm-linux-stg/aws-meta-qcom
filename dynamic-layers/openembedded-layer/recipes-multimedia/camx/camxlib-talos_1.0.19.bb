PLATFORM = "talos"
PBT_BUILD_DATE = "260424"

require common.inc

SRC_URI[camxlib.sha256sum]     = "51a1bf62ddfef442d44c44a83b8a045f127b214eeeb3b855cd1c310c698766d8"
SRC_URI[camx.sha256sum]        = "dd2142bcf8cfbc989d7c42b416314d424f08e198ded488b5a0d67f0b2fb3a137"
SRC_URI[chicdk.sha256sum]      = "969f860c8c931e5a3673b8dea3c7cd9230d7b89c55b86f6a5e5a4da2128c9687"
SRC_URI[camxcommon.sha256sum]  = "4f31213d5bf56d5091c43612a23ec440c94153f1e49c3b8e991d435f1f9f13a8"
